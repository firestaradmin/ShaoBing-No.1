# Keil uVision project ShaoBing_No_1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ShaoBing_No_1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\User;..\Lib\FWLib\inc;..\Lib\CMSIS;..\Drive
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group DOC
    ../Doc/: 规划.txt Readme.txt
  group CORE
    ../Lib/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Lib/CMSIS/STARTUP/: startup_stm32f10x_md.s
  group FWLIB
    ../Lib/FWLib/src/: stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c misc.c
  group USER
    ../User/: delay.c main.c myKey.c myShaoBingApp.c myUSART.c AT24C04.c
  group DRIVE
    ../Drive/: DS18B20.c OLED_I2C_Buffer.c
